Commit message: edited 2-segment URDF to have correct shape and joint pos

File: robot_project/models/2-segment-arm.urdf (robot description, URDF)
Before this commit: robot roco_arm, 3 links, 2 joints
Joints:
- joint first_to_second: origin xyz=0 0 0.03 -> xyz=-0.6 0 0
